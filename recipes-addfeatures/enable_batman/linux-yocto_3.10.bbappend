FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://enable_batman.cfg"
