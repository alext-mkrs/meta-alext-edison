IMAGE_INSTALL += "motion v4l-utils"

# Python modules to be able to install pip
IMAGE_INSTALL += "python-json python-pkgutil python-audio python-image python-email python-netserver python-xmlrpc python-distutils python-ctypes python-html python-compile python-misc python-numbers python-unittest python-difflib"
