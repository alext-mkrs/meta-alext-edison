FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://enable_cp210x.cfg"
