FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://enable_btusb.cfg"
