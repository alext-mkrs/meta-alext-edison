FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://gspca_pac7302_webcam.cfg"
